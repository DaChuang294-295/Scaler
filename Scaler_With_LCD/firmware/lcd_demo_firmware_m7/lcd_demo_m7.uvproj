# Keil uVision project lcd_demo_m7.uvproj, settings and files
target CME_M7 (ARM-ADS)
  device: M7 Capital Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: lcd_demo_m7 +hex
  c flags: Optim=1
  c include: .\lib_arm_files
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: main.c
  group lib_arm
    ./lib_arm_files/: cmem7_gpio.c cmem7_misc.c cmem7_spi.c cmem7_uart.c system_cmem7.c startup_cmem7.s cmem7_ddr.c
